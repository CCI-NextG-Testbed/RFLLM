options:
  parameters:
    generate_options: qt_gui
    id: Channel_RX_Scheme
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: noise_amp
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 40e6
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_amp
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: noise_amp
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/rapcole12/Documents/RFLLM/performance_analysis/ref_payload.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/rapcole12/Documents/RFLLM/dataset/wifi/pred.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/rapcole12/Documents/RFLLM/dataset/wifi/gt.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_1
  id: blocks_file_source
  parameters:
    file: /home/rapcole12/Documents/RFLLM/performance_analysis/ref_payload.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '10000'
    type: float
  states: {}
- name: blocks_keep_one_in_n_1
  id: blocks_keep_one_in_n
  parameters:
    n: '10000'
    type: float
  states: {}
- name: blocks_keep_one_in_n_2
  id: blocks_keep_one_in_n
  parameters:
    n: '10000'
    type: float
  states: {}
- name: blocks_keep_one_in_n_3
  id: blocks_keep_one_in_n
  parameters:
    n: '10000'
    type: float
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '8192'
    max_iter: '4000'
    scale: 1/8192
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '8192'
    max_iter: '4000'
    scale: 1/8192
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '8192'
    max_iter: '4000'
    scale: 1/8192
    type: float
  states: {}
- name: blocks_moving_average_xx_0_1
  id: blocks_moving_average_xx
  parameters:
    length: '8192'
    max_iter: '4000'
    scale: 1/8192
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '10'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '10'
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '1'
    type: float
  states: {}
- name: blocks_stream_to_tagged_stream_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '1'
    type: float
  states: {}
- name: blocks_stream_to_tagged_stream_2
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '1'
    type: float
  states: {}
- name: blocks_stream_to_tagged_stream_3
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '1'
    type: float
  states: {}
- name: blocks_stream_to_tagged_stream_4
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"ref_payload"'
    packet_len: '96'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_4_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"ref_payload"'
    packet_len: '96'
    type: byte
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.0'
    seed: '0'
    taps: '1.0'
  states: {}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.0'
    seed: '0'
    taps: '1.0'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport time\nimport pmt\nimport math\n\nclass blk(gr.sync_block):\n    def __init__(self, snr_in_db=False):\n        gr.sync_block.__init__(self, name=\"rx_metrics_to_numbers\",\n                               in_sig=None, out_sig=[np.float32, np.float32, np.float32])\n\n        self.message_port_register_in(pmt.intern(\"in\"))\n        self.set_msg_handler(pmt.intern(\"in\"), self.handle_msg)\n\n        self.snr_in_db = bool(snr_in_db)\n\n        # Hold last values (Number Sink will display these)\n        self.cfo = np.float32(0.0)\n        self.snr = np.float32(0.0)\n        self.rssi = np.float32(0.0)\n\n    def _get(self, d, key):\n        k = pmt.intern(key)\n\n        # Case 1: PMT dict\n        if pmt.is_dict(d) and pmt.dict_has_key(d, k):\n            v = pmt.dict_ref(d, k, pmt.PMT_NIL)\n            if pmt.is_number(v):\n                return float(pmt.to_double(v))\n\n        # Case 2: association list (alist): ((key . val) (key . val) ...)\n        cur = d\n        while pmt.is_pair(cur):\n            item = pmt.car(cur)      # (key . val)\n            cur = pmt.cdr(cur)\n            if pmt.is_pair(item):\n                kk = pmt.car(item)\n                vv = pmt.cdr(item)\n                if pmt.equal(kk, k) and pmt.is_number(vv):\n                    return float(pmt.to_double(vv))\n\n        return None\n\n    def handle_msg(self, msg):\n        # If this is a PDU, msg = (meta, data). If not, it might be a dict or an alist.\n        d = msg\n\n        if pmt.is_pair(msg):\n            meta = pmt.car(msg)\n            data = pmt.cdr(msg)\n            # Only treat as PDU if meta is a dict (common PDU convention)\n            if pmt.is_dict(meta):\n                d = meta\n            else:\n                # Otherwise it's likely an alist like: ((k . v) (k . v) ...)\n                d = msg\n\n        # Now extract values from d (dict OR alist)\n        cfo = self._get(d, \"cfo_hz\") or self._get(d, \"cfo\")\n        snr = self._get(d, \"snr\") or self._get(d, \"snr_lin\") or self._get(d, \"snr_db\")\n        rssi = self._get(d, \"rssi\") or self._get(d, \"rx_power\")\n\n        if cfo is not None:\n            self.cfo = np.float32(cfo / 1e3)\n\n        if snr is not None:\n            if self.snr_in_db:\n                snr_db = 10.0 * math.log10(max(1e-12, snr))  # assumes snr is linear\n                self.snr = np.float32(snr_db)\n            else:\n                self.snr = np.float32(snr)\n\n        if rssi is not None:\n            self.rssi = np.float32(rssi)\n\n\n    def work(self, input_items, output_items):\n        # output constant streams = last known values\n        output_items[0][:] = self.cfo   # CFO (Hz)\n        output_items[1][:] = self.snr   # SNR (linear or dB)\n        output_items[2][:] = self.rssi  # RSSI\n        return len(output_items[0])\n\n"
    snr_in_db: 'True'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport time\nimport pmt\nimport math\n\nclass blk(gr.sync_block):\n    def __init__(self, snr_in_db=False):\n        gr.sync_block.__init__(self, name=\"rx_metrics_to_numbers\",\n                               in_sig=None, out_sig=[np.float32, np.float32, np.float32])\n\n        self.message_port_register_in(pmt.intern(\"in\"))\n        self.set_msg_handler(pmt.intern(\"in\"), self.handle_msg)\n\n        self.snr_in_db = bool(snr_in_db)\n\n        # Hold last values (Number Sink will display these)\n        self.cfo = np.float32(0.0)\n        self.snr = np.float32(0.0)\n        self.rssi = np.float32(0.0)\n\n    def _get(self, d, key):\n        k = pmt.intern(key)\n\n        # Case 1: PMT dict\n        if pmt.is_dict(d) and pmt.dict_has_key(d, k):\n            v = pmt.dict_ref(d, k, pmt.PMT_NIL)\n            if pmt.is_number(v):\n                return float(pmt.to_double(v))\n\n        # Case 2: association list (alist): ((key . val) (key . val) ...)\n        cur = d\n        while pmt.is_pair(cur):\n            item = pmt.car(cur)      # (key . val)\n            cur = pmt.cdr(cur)\n            if pmt.is_pair(item):\n                kk = pmt.car(item)\n                vv = pmt.cdr(item)\n                if pmt.equal(kk, k) and pmt.is_number(vv):\n                    return float(pmt.to_double(vv))\n\n        return None\n\n    def handle_msg(self, msg):\n        # If this is a PDU, msg = (meta, data). If not, it might be a dict or an alist.\n        d = msg\n\n        if pmt.is_pair(msg):\n            meta = pmt.car(msg)\n            data = pmt.cdr(msg)\n            # Only treat as PDU if meta is a dict (common PDU convention)\n            if pmt.is_dict(meta):\n                d = meta\n            else:\n                # Otherwise it's likely an alist like: ((k . v) (k . v) ...)\n                d = msg\n\n        # Now extract values from d (dict OR alist)\n        cfo = self._get(d, \"cfo_hz\") or self._get(d, \"cfo\")\n        snr = self._get(d, \"snr\") or self._get(d, \"snr_lin\") or self._get(d, \"snr_db\")\n        rssi = self._get(d, \"rssi\") or self._get(d, \"rx_power\")\n\n        if cfo is not None:\n            self.cfo = np.float32(cfo / 1e3)\n\n        if snr is not None:\n            if self.snr_in_db:\n                snr_db = 10.0 * math.log10(max(1e-12, snr))  # assumes snr is linear\n                self.snr = np.float32(snr_db)\n            else:\n                self.snr = np.float32(snr)\n\n        if rssi is not None:\n            self.rssi = np.float32(rssi)\n\n\n    def work(self, input_items, output_items):\n        # output constant streams = last known values\n        output_items[0][:] = self.cfo   # CFO (Hz)\n        output_items[1][:] = self.snr   # SNR (linear or dB)\n        output_items[2][:] = self.rssi  # RSSI\n        return len(output_items[0])\n\n"
    snr_in_db: 'True'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "# ber_from_stats.py\n#\n# GNU Radio Embedded Python Block\n# - Input: message PMT dict on port \"stats\"\n# - Output: float stream (BER)\n#\n# Expects PMT dict like:\n#   ((ber . 0.478723))\n\nimport numpy as np\nimport pmt\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):\n    def __init__(self, dict_key=\"ber\", emit_nan_if_missing=True, debug=False):\n        gr.sync_block.__init__(\n            self,\n            name=\"metric_from_stats\",\n            in_sig=None,\n            out_sig=[np.float32],\n        )\n\n        self.dict_key = str(dict_key)\n        self.emit_nan_if_missing = bool(emit_nan_if_missing)\n        self.debug = bool(debug)\n\n        # Message input\n        self.message_port_register_in(pmt.intern(\"stats\"))\n        self.set_msg_handler(pmt.intern(\"stats\"), self._handle_stats)\n\n        self._have = False\n        self._last = np.float32(np.nan)\n\n    # -------------------------\n    # Message handler\n    # -------------------------\n    def _handle_stats(self, msg):\n        try:\n            payload = msg\n\n            # Expect a dict directly\n            if not pmt.is_dict(payload):\n                if self.debug:\n                    print(\"[MEAN_LLR_FROM_STATS] payload is not a dict:\", payload)\n                if self.emit_nan_if_missing:\n                    self._last = np.float32(np.nan)\n                    self._have = True\n                return\n\n            key = pmt.intern(self.dict_key)\n            val = pmt.dict_ref(payload, key, pmt.PMT_NIL)\n\n            if val is pmt.PMT_NIL:\n                if self.debug:\n                    print(f\"[MEAN_LLR_FROM_STATS] key '{self.dict_key}' missing\")\n                if self.emit_nan_if_missing:\n                    self._last = np.float32(np.nan)\n                    self._have = True\n                return\n\n            # Convert PMT to float\n            if pmt.is_real(val):\n                ber = float(pmt.to_double(val))\n            elif pmt.is_integer(val):\n                ber = float(pmt.to_long(val))\n            elif pmt.is_bool(val):\n                ber = 1.0 if pmt.to_bool(val) else 0.0\n            else:\n                ber = float(pmt.to_python(val))\n\n            self._last = np.float32(ber)\n            self._have = True\n\n            if self.debug:\n                print(f\"[MEAN_LLR_FROM_STATS] mean_llr={ber:.6e}\")\n\n        except Exception as e:\n            if self.debug:\n                print(\"[MEAN_LLR_FROM_STATS] exception:\", repr(e))\n            if self.emit_nan_if_missing:\n                self._last = np.float32(np.nan)\n                self._have = True\n\n    # -------------------------\n    # Stream output\n    # -------------------------\n    def work(self, input_items, output_items):\n        out = output_items[0]\n        n = len(out)\n\n        if not self._have:\n            out[:] = np.float32(np.nan)\n            return n\n\n        out[:] = self._last\n        return n\n\n"
    debug: 'False'
    dict_key: '"mean_abs_llr"'
    emit_nan_if_missing: 'False'
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: "# ber_from_stats.py\n#\n# GNU Radio Embedded Python Block\n# - Input: message PMT dict on port \"stats\"\n# - Output: float stream (BER)\n#\n# Expects PMT dict like:\n#   ((ber . 0.478723))\n\nimport numpy as np\nimport pmt\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):\n    def __init__(self, dict_key=\"ber\", emit_nan_if_missing=True, debug=False):\n        gr.sync_block.__init__(\n            self,\n            name=\"metric_from_stats\",\n            in_sig=None,\n            out_sig=[np.float32],\n        )\n\n        self.dict_key = str(dict_key)\n        self.emit_nan_if_missing = bool(emit_nan_if_missing)\n        self.debug = bool(debug)\n\n        # Message input\n        self.message_port_register_in(pmt.intern(\"stats\"))\n        self.set_msg_handler(pmt.intern(\"stats\"), self._handle_stats)\n\n        self._have = False\n        self._last = np.float32(np.nan)\n\n    # -------------------------\n    # Message handler\n    # -------------------------\n    def _handle_stats(self, msg):\n        try:\n            payload = msg\n\n            # Expect a dict directly\n            if not pmt.is_dict(payload):\n                if self.debug:\n                    print(\"[MEAN_LLR_FROM_STATS] payload is not a dict:\", payload)\n                if self.emit_nan_if_missing:\n                    self._last = np.float32(np.nan)\n                    self._have = True\n                return\n\n            key = pmt.intern(self.dict_key)\n            val = pmt.dict_ref(payload, key, pmt.PMT_NIL)\n\n            if val is pmt.PMT_NIL:\n                if self.debug:\n                    print(f\"[MEAN_LLR_FROM_STATS] key '{self.dict_key}' missing\")\n                if self.emit_nan_if_missing:\n                    self._last = np.float32(np.nan)\n                    self._have = True\n                return\n\n            # Convert PMT to float\n            if pmt.is_real(val):\n                ber = float(pmt.to_double(val))\n            elif pmt.is_integer(val):\n                ber = float(pmt.to_long(val))\n            elif pmt.is_bool(val):\n                ber = 1.0 if pmt.to_bool(val) else 0.0\n            else:\n                ber = float(pmt.to_python(val))\n\n            self._last = np.float32(ber)\n            self._have = True\n\n            if self.debug:\n                print(f\"[MEAN_LLR_FROM_STATS] mean_llr={ber:.6e}\")\n\n        except Exception as e:\n            if self.debug:\n                print(\"[MEAN_LLR_FROM_STATS] exception:\", repr(e))\n            if self.emit_nan_if_missing:\n                self._last = np.float32(np.nan)\n                self._have = True\n\n    # -------------------------\n    # Stream output\n    # -------------------------\n    def work(self, input_items, output_items):\n        out = output_items[0]\n        n = len(out)\n\n        if not self._have:\n            out[:] = np.float32(np.nan)\n            return n\n\n        out[:] = self._last\n        return n\n\n"
    debug: 'False'
    dict_key: '"mean_abs_llr"'
    emit_nan_if_missing: 'False'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: "import os\nimport time\nimport numpy as np\nimport pmt\nfrom gnuradio import gr\n\n\nclass blk(gr.basic_block):\n    def __init__(self, amp=0, filename=\"snr_mean_llr_log.csv\"):\n        gr.basic_block.__init__(\n            self,\n            name=\"npr_metric_logger\",\n            in_sig=None,\n            out_sig=None,\n        )\n\n        # -------------------------\n        # Message ports\n        # -------------------------\n        for port in (\"npr1\", \"metric1\", \"npr2\", \"metric2\"):\n            self.message_port_register_in(pmt.intern(port))\n\n        self.set_msg_handler(pmt.intern(\"npr1\"), self.h_npr1)\n        self.set_msg_handler(pmt.intern(\"metric1\"), self.h_ber1)\n        self.set_msg_handler(pmt.intern(\"npr2\"), self.h_npr2)\n        self.set_msg_handler(pmt.intern(\"metric2\"), self.h_ber2)\n\n        self.amp = amp\n\n        # Latest cached values\n        self.latest_npr1 = None\n        self.latest_npr2 = None\n        self.latest_ber1 = None\n        self.latest_ber2 = None\n\n        self.last_write = time.time()\n        self.write_period = 2.0  # seconds\n\n        # -------------------------\n        # File setup (append mode)\n        # -------------------------\n        self.filename = os.path.abspath(filename)\n        file_exists = os.path.exists(self.filename)\n\n        self.f = open(self.filename, \"a\", buffering=1)\n\n        if not file_exists:\n            self.f.write(\"snr1_db,metric1,snr2_db,metric2,amp\\n\")\n            self.f.flush()\n\n        print(f\"[LOGGER] Appending to CSV: {self.filename}\")\n\n    # -------------------------\n    # Message handlers\n    # -------------------------\n    def h_npr1(self, msg):\n        self.latest_npr1 = self._to_float(msg)\n\n    def h_npr2(self, msg):\n        self.latest_npr2 = self._to_float(msg)\n\n    def h_ber1(self, msg):\n        self.latest_ber1 = self._to_float(msg)\n        self._maybe_write()\n\n    def h_ber2(self, msg):\n        self.latest_ber2 = self._to_float(msg)\n        self._maybe_write()\n\n    # -------------------------\n    # Core writer\n    # -------------------------\n    def _maybe_write(self):\n        now = time.time()\n\n        # Rate limit\n        if now - self.last_write < self.write_period:\n            return\n\n        # Need NPRs at minimum\n        if self.latest_npr1 is None or self.latest_npr2 is None:\n            return\n\n        b1 = self.latest_ber1 if self.latest_ber1 is not None else float(\"nan\")\n        b2 = self.latest_ber2 if self.latest_ber2 is not None else float(\"nan\")\n\n        self.f.write(\n            f\"{self.latest_npr1:.6f},{b1:.8e},\"\n            f\"{self.latest_npr2:.6f},{b2:.8e},{self.amp}\\n\"\n        )\n        self.f.flush()\n        os.fsync(self.f.fileno())\n\n        print(\n            f\"[LOGGER] t={now:.1f} \"\n            f\"NPR1={self.latest_npr1:.2f} \"\n            f\"Metric1={b1:.2e}\"\n        )\n\n        self.last_write = now\n\n    # -------------------------\n    # Helpers\n    # -------------------------\n    def _to_float(self, msg):\n        payload = pmt.cdr(msg) if pmt.is_pair(msg) else msg\n\n        if pmt.is_f32vector(payload):\n            return float(pmt.f32vector_elements(payload)[0])\n\n        try:\n            v = pmt.to_python(payload)\n            if isinstance(v, (list, tuple)) and len(v):\n                return float(v[0])\n            if isinstance(v, (int, float)):\n                return float(v)\n        except Exception:\n            pass\n\n        return None\n\n    def stop(self):\n        try:\n            self.f.flush()\n            os.fsync(self.f.fileno())\n            self.f.close()\n            print(f\"[LOGGER] Closed CSV: {self.filename}\")\n        except Exception:\n            pass\n        return True\n\n"
    amp: noise_amp
    filename: '''snr_mean_llr_2curves.csv'''
  states: {}
- name: ieee80211_decode_0
  id: ieee80211_decode
  parameters:
    ifdebug: 'True'
  states: {}
- name: ieee80211_decode_1
  id: ieee80211_decode
  parameters:
    ifdebug: 'True'
  states: {}
- name: ieee80211_demod_0
  id: ieee80211_demod
  parameters:
    mugid: '2'
    mupos: '0'
  states: {}
- name: ieee80211_demod_0_0
  id: ieee80211_demod
  parameters:
    mugid: '2'
    mupos: '0'
  states: {}
- name: ieee80211_signal_0
  id: ieee80211_signal
  parameters: {}
  states: {}
- name: ieee80211_signal_0_0
  id: ieee80211_signal
  parameters: {}
  states: {}
- name: ieee80211_sync_0
  id: ieee80211_sync
  parameters: {}
  states: {}
- name: ieee80211_sync_0_0
  id: ieee80211_sync
  parameters: {}
  states: {}
- name: ieee80211_trigger_0
  id: ieee80211_trigger
  parameters: {}
  states: {}
- name: ieee80211_trigger_0_0
  id: ieee80211_trigger
  parameters: {}
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 10e6
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 2e6
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 10e6
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 2e6
    win: window.WIN_HAMMING
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: float
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: float
  states: {}
- name: pdu_tagged_stream_to_pdu_0_1
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: float
  states: {}
- name: pdu_tagged_stream_to_pdu_0_2
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: float
  states: {}
- name: pdu_tagged_stream_to_pdu_1
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: ref_payload
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_1_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: ref_payload
    type: byte
  states: {}
- name: presiso_0
  id: presiso
  parameters: {}
  states: {}
- name: presiso_0_0
  id: presiso
  parameters: {}
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_number_sink_1_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_number_sink_1_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_number_sink_1_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_number_sink_1_3
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: pred_npr
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: gt_ber
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: gt_npr
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: pred_ber
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: gt_npr
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: gt_ber
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: pred_ber
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: pred_npr
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [analog_noise_source_x_0_0, '0', blocks_add_xx_0_0, '1']
- [analog_noise_source_x_0_0, '0', blocks_complex_to_mag_squared_0_0_0, '0']
- [blocks_add_xx_0, '0', low_pass_filter_0, '0']
- [blocks_add_xx_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_complex_to_mag_squared_0_0_0, '0', blocks_moving_average_xx_0_0_0, '0']
- [blocks_complex_to_mag_squared_0_1, '0', blocks_moving_average_xx_0_1, '0']
- [blocks_divide_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_divide_xx_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_4_0, '0']
- [blocks_file_source_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_file_source_0_0, '0', channels_channel_model_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_complex_to_mag_squared_0_1, '0']
- [blocks_file_source_0_0_0, '0', channels_channel_model_0_0, '0']
- [blocks_file_source_0_1, '0', blocks_stream_to_tagged_stream_4, '0']
- [blocks_keep_one_in_n_0, '0', blocks_stream_to_tagged_stream_2, '0']
- [blocks_keep_one_in_n_1, '0', blocks_stream_to_tagged_stream_1, '0']
- [blocks_keep_one_in_n_2, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_keep_one_in_n_3, '0', blocks_stream_to_tagged_stream_3, '0']
- [blocks_moving_average_xx_0, '0', blocks_divide_xx_0, '1']
- [blocks_moving_average_xx_0_0, '0', blocks_divide_xx_0, '0']
- [blocks_moving_average_xx_0_0_0, '0', blocks_divide_xx_0_0, '0']
- [blocks_moving_average_xx_0_1, '0', blocks_divide_xx_0_0, '1']
- [blocks_multiply_const_vxx_0, '0', qtgui_number_sink_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_number_sink_1_3, '0']
- [blocks_nlog10_ff_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_nlog10_ff_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', pdu_tagged_stream_to_pdu_0_1, '0']
- [blocks_stream_to_tagged_stream_1, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [blocks_stream_to_tagged_stream_2, '0', pdu_tagged_stream_to_pdu_0_2, '0']
- [blocks_stream_to_tagged_stream_3, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_stream_to_tagged_stream_4, '0', pdu_tagged_stream_to_pdu_1_0, '0']
- [blocks_stream_to_tagged_stream_4_0, '0', pdu_tagged_stream_to_pdu_1, '0']
- [channels_channel_model_0, '0', blocks_add_xx_0, '0']
- [channels_channel_model_0_0, '0', blocks_add_xx_0_0, '0']
- [epy_block_0, '0', qtgui_number_sink_0, '0']
- [epy_block_0, '1', virtual_sink_0, '0']
- [epy_block_0, '2', qtgui_number_sink_1_0, '0']
- [epy_block_0_0, '0', qtgui_number_sink_1_2, '0']
- [epy_block_0_0, '1', virtual_sink_2, '0']
- [epy_block_0_0, '2', qtgui_number_sink_1_1, '0']
- [epy_block_1, '0', virtual_sink_3, '0']
- [epy_block_1_0, '0', virtual_sink_1, '0']
- [ieee80211_decode_0, out, blocks_message_debug_0, store]
- [ieee80211_decode_0, stats, epy_block_0, in]
- [ieee80211_decode_0, stats, epy_block_1, stats]
- [ieee80211_decode_1, out, blocks_message_debug_0_0, store]
- [ieee80211_decode_1, stats, epy_block_0_0, in]
- [ieee80211_decode_1, stats, epy_block_1_0, stats]
- [ieee80211_demod_0, '0', ieee80211_decode_0, '0']
- [ieee80211_demod_0_0, '0', ieee80211_decode_1, '0']
- [ieee80211_signal_0, '0', ieee80211_demod_0, '0']
- [ieee80211_signal_0_0, '0', ieee80211_demod_0_0, '0']
- [ieee80211_sync_0, '0', ieee80211_signal_0, '0']
- [ieee80211_sync_0_0, '0', ieee80211_signal_0_0, '0']
- [ieee80211_trigger_0, '0', ieee80211_sync_0, '0']
- [ieee80211_trigger_0_0, '0', ieee80211_sync_0_0, '0']
- [low_pass_filter_0, '0', ieee80211_signal_0, '1']
- [low_pass_filter_0, '0', ieee80211_sync_0, '2']
- [low_pass_filter_0, '0', presiso_0, '0']
- [low_pass_filter_0_0, '0', ieee80211_signal_0_0, '1']
- [low_pass_filter_0_0, '0', ieee80211_sync_0_0, '2']
- [low_pass_filter_0_0, '0', presiso_0_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, epy_block_2, npr1]
- [pdu_tagged_stream_to_pdu_0_0, pdus, epy_block_2, npr2]
- [pdu_tagged_stream_to_pdu_0_1, pdus, epy_block_2, metric2]
- [pdu_tagged_stream_to_pdu_0_2, pdus, epy_block_2, metric1]
- [pdu_tagged_stream_to_pdu_1, pdus, ieee80211_decode_0, ref_payload]
- [pdu_tagged_stream_to_pdu_1_0, pdus, ieee80211_decode_1, ref_payload]
- [presiso_0, '0', ieee80211_trigger_0, '0']
- [presiso_0, '1', ieee80211_sync_0, '1']
- [presiso_0_0, '0', ieee80211_trigger_0_0, '0']
- [presiso_0_0, '1', ieee80211_sync_0_0, '1']
- [virtual_source_0, '0', blocks_keep_one_in_n_3, '0']
- [virtual_source_1, '0', blocks_keep_one_in_n_0, '0']
- [virtual_source_2, '0', blocks_keep_one_in_n_2, '0']
- [virtual_source_3, '0', blocks_keep_one_in_n_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
